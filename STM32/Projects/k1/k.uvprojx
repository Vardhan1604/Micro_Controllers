# Keil uVision project k.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: k +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
