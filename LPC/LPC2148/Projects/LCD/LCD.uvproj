# Keil uVision project LCD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LCD +hex
  c flags: Optim=1
  c include: ..\..\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c GPIO.h
    ../../Drivers/LCD_4Bit_Mode/: LCD.c
    ../../../../8051/NOV_24 _Projects/Lib/Delay/: Delay.c
