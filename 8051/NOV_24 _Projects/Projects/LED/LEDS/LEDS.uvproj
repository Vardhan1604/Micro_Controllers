# Keil uVision project LEDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: LEDS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../../Lib/Digital_Write/: Digital_Write.c
    ../../../Lib/Delay/: Delay.c
    ../../../Lib/Digital_Read/: Digital_Read.c
