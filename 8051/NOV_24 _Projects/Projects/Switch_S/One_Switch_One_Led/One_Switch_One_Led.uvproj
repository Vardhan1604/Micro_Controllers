# Keil uVision project One_Switch_One_Led.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: One_Switch_One_Led +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../../Lib/LED/: LED.c
    ../../../Lib/Switch/: Switch.c
    ../../../Lib/Delay/: Delay.c
