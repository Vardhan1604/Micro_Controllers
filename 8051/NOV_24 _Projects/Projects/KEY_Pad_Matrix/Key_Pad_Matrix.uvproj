# Keil uVision project Key_Pad_Matrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: Key_Pad_Matrix
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../Lib/Delay/: Delay.c
    ../../Lib/LCD/: LCD.c
    ../../Lib/Matrix_Key_Pad/: KEYPAD.c
